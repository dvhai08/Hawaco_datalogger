# Keil uVision project DTG02.uvprojx, settings and files
target DTG02 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L083RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: DTG02 +hex
  AfterMake: fromelf.exe --bin -o  "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32L083xx,RTC_BACKUP_VALID_DATA=0x12345613,DEBUG_MODE,UMM_MALLOC_CFG_HEAP_SIZE=6144,USER_VECT_TAB_ADDRESS,WDT_ENABLE,DTG02,BUFFER_SIZE_UP=512
  c include: ../Core/Inc;                               ../Drivers/STM32L0xx_HAL_Driver/Inc;                               ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;                               ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;                               ../Drivers/CMSIS/Include;                               ..\..\src\SEGGER_RTT_V698b\RTT;                               ..\..\src\app_cli;                               ..\..\src\app_queue;                               ..\..\src\fault;                               ..\..\src\app_debug;                               ..\..\src\gsm;                               ..\..\src\inc;                               ..\..\src\umm_malloc-1.0.1\src;                               ..\..\src\lwrb\lwrb\src\include\lwrb;                               ..\..\src\utilities;                               ..\..\src\measurement;                               ..\..\src\app_rtc;                               ..\..\src\server_msg;                               ..\..\src\app_spi_flash;                               ..\..\src\app_eeprom;                               ..\..\src\lowpass_filter;                               ..\..\src\umm_malloc-1.0.1\src;                               ..\..\src\sys_ctx;                               ..\..\src\ota_update;                               ..\..\src\app_md5;                               ..\..\src\app_sync;                               ..\..\src\app_bkup;                               ..\..\src\modbus_master
  memory RVCT4: ROM 0x8002000 size 0x16800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l083xx.s
  group Application/User/Core
    ../../src/inc/: version_control.h
    ../../src/version_control/: version_control.c
    ../Core/Inc/: spi.h usart.h rtc.h gpio.h main.h
    ../Core/Src/: main.c gpio.c adc.c crc.c dma.c iwdg.c usart.c rtc.c spi.c tim.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_gpio.c stm32l0xx_ll_adc.c stm32l0xx_ll_dma.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_ll_rcc.c stm32l0xx_ll_utils.c stm32l0xx_ll_exti.c stm32l0xx_ll_crc.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_usart.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_ll_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_ll_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group segger_rtt
    ../../src/SEGGER_RTT_V698b/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group app_cli
    ../../src/app_cli/: app_cli.c app_cli.h app_shell.c app_shell.h
  group app_queue
    ../../src/app_queue/: app_queue.h
  group app_debug
    ../../src/app_debug/: app_debug.c app_debug.h
  group gsm
    ../../src/gsm/: gsm_data_layer.c gsm.h gsm_hardware_layer.c gsm_http.c gsm_http.h gsm_sms.c gsm_utilities.c gsm_utilities.h
  group lowpass_filter
    ../../src/lowpass_filter/: lpf.c lpf.h
  group lwrb
    ../../src/lwrb/lwrb/src/lwrb/: lwrb.c
    ../../src/lwrb/lwrb/src/include/lwrb/: lwrb.h
  group modbus_master
    ../../src/modbus_master/: crc16.h modbus_master.c modbus_master.h ringbuffer.c ringbuffer.h word.h modbus_memory.c modbus_memory.h
  group driver_uart
    ../../src/src/: hardware_manager.c
  group measurement
    ../../src/measurement/: control_output.c measure_input.c measure_input.h control_output.h
  group app_rtc
    ../../src/app_rtc/: app_rtc.h app_rtc.c
  group eeprom
    ../../src/app_eeprom/: app_eeprom.c app_eeprom.h
  group server_msg
    ../../src/server_msg/: server_msg.c server_msg.h
  group app_flash
    ../../src/app_spi_flash/: app_spi_flash.c app_spi_flash.h
  group umm_malloc
    ../../src/umm_malloc-1.0.1/src/: umm_info.c umm_integrity.c umm_malloc.c umm_malloc.h umm_malloc_cfg.h umm_poison.c
  group utilities
    ../../src/utilities/: utilities.c utilities.h
  group sys_ctx
    ../../src/sys_ctx/: sys_ctx.c sys_ctx.h
  group ota_update
    ../../src/ota_update/: ota_update.c ota_update.h
  group app_md5
    ../../src/app_md5/: app_md5.c app_md5.h
  group app_sync
    ../../src/app_sync/: app_sync.c app_sync.h clist.h sync_drv.c sync_drv.h
  group app_backup
    ../../src/app_bkup/: app_bkup.c app_bkup.h
  group flash_if
    ../../src/ota_update/: flash_if.c flash_if.h
software components: CMSIS:CORE 4.3.0
