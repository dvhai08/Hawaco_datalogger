# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L083RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: Bootloader +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32L083xx,USE_HAL_DRIVER,USE_FULL_ASSERT
  c include: ../Core/Inc;    ../Drivers/STM32L0xx_HAL_Driver/Inc;    ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;    ../Drivers/CMSIS/Include;    ..\..\src\SEGGER_RTT_V698b\RTT;    ..\..\src\app_cli;    ..\..\src\app_queue;    ..\..\src\fault;    ..\..\src\app_debug;    ..\..\src\gsm;    ..\..\src\inc;    ..\..\src\umm_malloc-1.0.1\src;    ..\..\src\lwrb\lwrb\src\include\lwrb;    ..\..\src\utilities;    ..\..\src\measurement;    ..\..\src\app_rtc;    ..\..\src\server_msg;    ..\..\src\app_flash;    ..\..\src\app_eeprom;    ..\..\src\lowpass_filter;    ..\..\src\umm_malloc-1.0.1\src;    ..\..\src\sys_ctx;    ..\..\src\ota_update;    ..\..\src\app_md5;    ..\..\src\flash_if; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l083xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c iwdg.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_gpio.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_ll_rcc.c stm32l0xx_ll_utils.c stm32l0xx_ll_exti.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group ota_update
    ../../src/ota_update/: ota_update.c ota_update.h
  group flash_if
    ../../src/flash_if/: flash_if.c flash_if.h
software components: CMSIS:CORE 4.3.0
