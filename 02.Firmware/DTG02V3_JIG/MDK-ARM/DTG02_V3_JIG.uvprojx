# Keil uVision project DTG02_V3_JIG.uvprojx, settings and files
target DTG02_V3_JIG (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F072C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: DTG02_V3_JIG +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F072xB,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;           ../USB_DEVICE/App;           ../USB_DEVICE/Target;           ../Drivers/STM32F0xx_HAL_Driver/Inc;           ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;           ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;           ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;           ../Drivers/CMSIS/Include;           ..\app_debug;           ..\SEGGER_RTT_V698b\RTT;           ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;           ..\jsmn;           ..\lwrb\lwrb\src\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c iwdg.c tim.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_custom_hid_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_usb.c stm32f0xx_ll_gpio.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_ll_rcc.c stm32f0xx_ll_utils.c stm32f0xx_ll_exti.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_ll_adc.c stm32f0xx_ll_dma.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group app_debug
    ../app_debug/: app_debug.c app_debug.h
  group SEGGER_RTT
    ../SEGGER_RTT_V698b/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group jsmn
    ../jsmn/: jsmn.h
  group lwrb
    ../lwrb/lwrb/src/lwrb/: lwrb.c
    ../lwrb/lwrb/src/include/lwrb/: lwrb.h
software components: CMSIS:CORE 4.3.0
