# Keil uVision project Bootloader.uvproj, settings and files
target Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32E103VB GigaDevice
  cpu: IRAM(0x20000000-0x20007FFF)IROM(0x08000000-0x0801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Bootloader +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32E10X USE_IRC48M
  c misc: --c99
  c include: ..\inc;../../Library\CMSIS\GD\GD32E10x\Include;../../Library\GD32E10x_standard_peripheral\Include;..\..\..\..\..\Utilities;../../Library\CMSIS;../../Library\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../src/: app.c flash_if.c gd32e10x_it.c
  group CMSIS
    ../../Library/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group GD32E10x_Peripherals
    ../../Library/GD32E10x_standard_peripheral/Source/: gd32e10x_dma.c gd32e10x_exti.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_gpio.c gd32e10x_ctc.c
  group Startup
    ../../Library/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group Doc
    ../: readme.txt
