# Keil uVision project Project.uvprojx, settings and files
target GD32E103x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32E103CB GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HWC_GW_02 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32E10X,IRC8M_VALUE=8000000
  c include: ..\..\Library\CMSIS\GD\GD32E10x\Include;..\..\Library\GD32E10x_standard_peripheral\Include;..\..\Library\CMSIS\GD\GD32E10x\Source\ARM;..\inc;..\src\SEGGER_RTT_V698b\RTT;..\src\SEGGER_RTT_V698b\Syscalls;..\lwrb\lwrb\src\include\lwrb;..\..\Project;..\src\MQTTUser;..\src\MQTTPaho
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group TCPNet
    ../../Library/RL/TCPNet/Config/: Net_Config.c
    ../../Library/RL/TCPNet/: TCP_CM3.lib
  group Application
    ../src/: HardwareManager.c InitSystem.c main.c gd32e10x_it.c ControlOutput.c MeasureInput.c
  group Utilities
    ../src/: Debug.c Utilities.c
    ../lwrb/lwrb/src/lwrb/: lwrb.c
  group Peripheral
    ../src/: app_bkup.c app_wdt.c board_hw.c DriverUART.c InternalFlash.c
  group GSM
    ../src/GSM/: GSM_DataLayer.c GSM_HardwareLayer.c GSM_SMSLayer.c GSM_Utilities.c
  group MQTTUser
    ../src/MQTTUser/: MQTT_ClientMessage.c MQTT_HardwareLayer.c MQTT_ServerMessage.c
  group MQTTPaho
    ../src/MQTTPaho/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Encrypt
    ../src/: aes.c base64.c
  group SeggerRTT
    ../src/SEGGER_RTT_V698b/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group CMSIS
    ../../Library/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group GD32E103_PeriphLib
    ../../Library/GD32E10x_standard_peripheral/Source/: gd32e10x_adc.c gd32e10x_bkp.c gd32e10x_can.c gd32e10x_crc.c gd32e10x_ctc.c gd32e10x_dac.c gd32e10x_dbg.c gd32e10x_dma.c gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_fwdgt.c gd32e10x_gpio.c gd32e10x_i2c.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_rtc.c gd32e10x_spi.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_wwdgt.c
  group Startup
    ../../Library/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
